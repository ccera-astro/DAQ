options:
  parameters:
    generate_options: qt_gui
    id: n310_example
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: srate
  states: {}
- name: device
  id: parameter
  parameters:
    label: Device address string
    type: str
    value: '"type=n3xx,product=n310,addr=192.168.20.2"'
  states: {}
- name: frequency
  id: parameter
  parameters:
    label: Center Frequency (Hz)
    type: eng_float
    value: 1420.4058e6
  states: {}
- name: mclock
  id: parameter
  parameters:
    label: Master Clock Rate
    type: eng_float
    value: 125e6
  states: {}
- name: pps
  id: parameter
  parameters:
    label: PPS Clock SOurce
    type: str
    value: gpsdo
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: samp_rate
    fc: frequency
    fftsize: '2048'
    grid: 'True'
    name: Sky Spectrum (Hor/Ver)
    nconnections: '2'
    type: complex
  states: {}
- name: refclock
  id: parameter
  parameters:
    label: Reference clock type
    type: str
    value: gpsdo
  states: {}
- name: rfgain
  id: parameter
  parameters:
    label: RF Gain
    type: eng_float
    value: '65'
  states: {}
- name: srate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 12.5e6
  states: {}
- name: subdev
  id: parameter
  parameters:
    label: Sub-device spec
    type: str
    value: '"A:0 A:1"'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    center_freq0: uhd.tune_request(frequency,((samp_rate/2.0)+100e3))
    center_freq1: uhd.tune_request(frequency,((samp_rate/2.0)+100e3))
    clock_source0: refclock
    dev_addr: device
    dev_args: '"master_clock_rate=%f" % mclock'
    gain0: rfgain
    gain1: rfgain
    nchan: '2'
    samp_rate: samp_rate
    sd_spec0: subdev
    sync: gps_time
    time_source0: pps
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '1', qtgui_freq_sink_x_0, '1']

metadata:
  file_format: 1
