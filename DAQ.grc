options:
  parameters:
    generate_options: no_gui
    id: DAQ
    output_language: python
    run_options: run
    title: DAQ
  states: {}

blocks:
- name: alpha_IIR
  id: variable
  parameters:
    value: 2./decimation_factor
  states: {}
- name: base_name
  id: parameter
  parameters:
    label: Base File Name
    type: str
    value: Doppler
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: base_name+"_1.raw"
    type: float
    vlen: fft_size
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: base_name +"_2.raw"
    type: float
    vlen: fft_size
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(seconds*samp_rate)
    type: complex
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: float
    vlen: fft_size
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: decimation_factor
    type: float
    vlen: fft_size
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: decimation_factor
    type: float
    vlen: fft_size
  states: {}
- name: blocks_keep_one_in_n_2
  id: blocks_keep_one_in_n
  parameters:
    n: '50'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: decimation_factor
  id: parameter
  parameters:
    label: Decimation Factor
    type: intx
    value: '10000'
  states: {}
- name: device
  id: parameter
  parameters:
    label: Device address string
    type: str
    value: '"type=n3xx,product=n310,addr=192.168.20.2"'
  states: {}
- name: fft_size
  id: parameter
  parameters:
    label: fft_size
    type: intx
    value: '2048'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: frequency
  id: parameter
  parameters:
    label: Center Frequency (Hz)
    type: eng_float
    value: 1420.4e6
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: mclock
  id: parameter
  parameters:
    label: Master Clock Rate
    type: eng_float
    value: 125e6
  states: {}
- name: pps
  id: parameter
  parameters:
    label: PPS Clock SOurce
    type: str
    value: gpsdo
  states: {}
- name: refclock
  id: parameter
  parameters:
    label: Reference clock type
    type: str
    value: gpsdo
  states: {}
- name: rfgain
  id: parameter
  parameters:
    label: RF Gain
    type: eng_float
    value: '67.2'
  states: {}
- name: rx_time_catcher
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Catch the first rx_timestamp"""

          def __init__(self, rxfile="rxfile.txt",fftsize=32,crate=2500,srate=25e6):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='rx_time catcher',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.rxfile = rxfile
              self.first = True
              
              #
              # FFT outputs occur at srate/fftsize
              #
              self.fftrate = srate/fftsize
              
              #
              # This is then decimated at "self.decim" to produce the actual outputs
              #
              self.decim = self.fftrate / crate
              
              #
              # Which means the first output sample is produced at a time that is
              #  offset from the first input sample
              #
              self.offset = (1.0/self.fftrate) * self.decim

          def work(self, input_items, output_items):
              if (self.first == True):
                  # Get rx_time tag
                  self.first = False
                  tags = self.get_tags_in_window(0, 0, len(input_items[0]))
                  for tag in tags:
                      key = pmt.to_python(tag.key) # convert from PMT to python string
                      value = pmt.to_python(tag.value) # Note that the type(value) can be several things, it depends what PMT type it was
                      if (key == "rx_time"):
                          break
                  fp = open(self.rxfile, "w")
                  #fp.write("%s" % str(value))
                  timestump = float(value[0])+float(value[1])
                  timestump += self.offset
                  fp.write("%13.7f\n" % timestump)
                  fp.close()
              return len(input_items[0])
    crate: samp_rate/fft_size/decimation_factor
    fftsize: '32'
    rxfile: base_name + "_ts.txt"
    srate: samp_rate
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 1.25e7
  states: {}
- name: seconds
  id: parameter
  parameters:
    label: Seconds
    type: intx
    value: '3600'
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: alpha_IIR
    type: float
    vlen: fft_size
  states: {}
- name: single_pole_iir_filter_xx_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: alpha_IIR
    type: float
    vlen: fft_size
  states: {}
- name: subdev
  id: parameter
  parameters:
    label: Sub-device spec
    type: str
    value: '"A:0 A:1"'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    center_freq0: uhd.tune_request(frequency,((samp_rate/2.0)+100e3))
    center_freq1: uhd.tune_request(frequency,((samp_rate/2.0)+100e3))
    clock_source0: refclock
    dev_addr: device
    dev_args: '"master_clock_rate=%f" % mclock'
    gain0: rfgain
    gain1: rfgain
    nchan: '2'
    samp_rate: samp_rate
    sd_spec0: subdev
    sync: pc_clock_next_pps
    time_source0: pps
    type: fc32
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:14200
    timeout: '100'
    type: float
    vlen: fft_size
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', single_pole_iir_filter_xx_0_0, '0']
- [blocks_head_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_interleave_0, '0', zeromq_pub_sink_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_file_sink_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_interleave_0, '0']
- [blocks_keep_one_in_n_0_0, '0', blocks_file_sink_1, '0']
- [blocks_keep_one_in_n_0_0, '0', blocks_interleave_0, '1']
- [blocks_keep_one_in_n_2, '0', rx_time_catcher, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_keep_one_in_n_0, '0']
- [single_pole_iir_filter_xx_0_0, '0', blocks_keep_one_in_n_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_head_0, '0']
- [uhd_usrp_source_0, '1', blocks_keep_one_in_n_2, '0']
- [uhd_usrp_source_0, '1', blocks_stream_to_vector_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
