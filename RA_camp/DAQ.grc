options:
  parameters:
    generate_options: no_gui
    id: DAQ
    output_language: python
    run_options: run
    title: DAQ
  states: {}

blocks:
- name: alpha_IIR
  id: variable
  parameters:
    value: 2./decimation_factor
  states: {}
- name: base_name
  id: parameter
  parameters:
    label: Base File Name
    type: str
    value: Doppler
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: base_name+"_1.raw"
    type: float
    vlen: fft_size
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: base_name+"_2.raw"
    type: float
    vlen: fft_size
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(seconds*samp_rate)
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: decimation_factor
    type: float
    vlen: fft_size
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: decimation_factor
    type: float
    vlen: fft_size
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: decimation_factor
  id: parameter
  parameters:
    label: Decimation Factor
    type: intx
    value: '10000'
  states: {}
- name: device
  id: parameter
  parameters:
    label: Device address string
    type: str
    value: '"type=b200,num_recv_frames=256"'
  states: {}
- name: fft_size
  id: parameter
  parameters:
    label: fft_size
    type: intx
    value: '2048'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: frequency
  id: parameter
  parameters:
    label: Center Frequency (Hz)
    type: eng_float
    value: 1420.4e6
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: mclock
  id: parameter
  parameters:
    label: Master Clock Rate
    type: eng_float
    value: 20e6
  states: {}
- name: pps
  id: parameter
  parameters:
    label: PPS Clock SOurce
    type: str
    value: internal
  states: {}
- name: refclock
  id: parameter
  parameters:
    label: Reference clock type
    type: str
    value: internal
  states: {}
- name: rfgain
  id: parameter
  parameters:
    label: RF Gain
    type: eng_float
    value: '67.2'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 5e6
  states: {}
- name: seconds
  id: parameter
  parameters:
    label: Seconds
    type: intx
    value: '3600'
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: alpha_IIR
    type: float
    vlen: fft_size
  states: {}
- name: single_pole_iir_filter_xx_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: alpha_IIR
    type: float
    vlen: fft_size
  states: {}
- name: subdev
  id: parameter
  parameters:
    label: Sub-device spec
    type: str
    value: '"A:A"'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    center_freq0: uhd.tune_request(frequency,((samp_rate/2.0)+100e3))
    center_freq1: uhd.tune_request(frequency,((samp_rate/2.0)+100e3))
    clock_source0: refclock
    dev_addr: device
    dev_args: '"master_clock_rate=%f" % mclock'
    gain0: rfgain
    gain1: rfgain
    nchan: '2'
    samp_rate: samp_rate
    sd_spec0: subdev
    sync: pc_clock_next_pps
    time_source0: pps
    type: fc32
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:14200
    timeout: '100'
    type: float
    vlen: fft_size
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', single_pole_iir_filter_xx_0_0, '0']
- [blocks_head_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_file_sink_0, '0']
- [blocks_keep_one_in_n_0, '0', zeromq_pub_sink_0, '0']
- [blocks_keep_one_in_n_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_keep_one_in_n_0, '0']
- [single_pole_iir_filter_xx_0_0, '0', blocks_keep_one_in_n_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_head_0, '0']
- [uhd_usrp_source_0, '1', blocks_stream_to_vector_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
