options:
  parameters:
    generate_options: no_gui
    id: Pulsar
    output_language: python
    run_options: run
    title: Pulsar
  states: {}

blocks:
- name: alpha_IIR
  id: variable
  parameters:
    value: 2./decimation_factor
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '32'
  states: {}
- name: base_name
  id: parameter
  parameters:
    label: Base File Name
    type: str
    value: Pulsar
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: base_name+"_1.raw"
    type: float
    vlen: fft_size
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: base_name +"_2.raw"
    type: float
    vlen: fft_size
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(seconds*samp_rate)
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: decimation_factor
    type: float
    vlen: fft_size
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: decimation_factor
    type: float
    vlen: fft_size
  states: {}
- name: blocks_keep_one_in_n_2
  id: blocks_keep_one_in_n
  parameters:
    n: '50'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: decimation_factor
  id: parameter
  parameters:
    label: Decimation Factor
    type: intx
    value: '250'
  states: {}
- name: f1
  id: parameter
  parameters:
    label: '"Chan 1 freq"'
    type: eng_float
    value: 1420.4058e6
  states: {}
- name: f2
  id: parameter
  parameters:
    label: '"Chan 2 freq"'
    type: eng_float
    value: 1420.4058e6
  states: {}
- name: f3
  id: parameter
  parameters:
    label: '"Chan 3 freq"'
    type: eng_float
    value: 1420.4058e6
  states: {}
- name: f4
  id: parameter
  parameters:
    label: '"Chan 4 freq"'
    type: eng_float
    value: 1420.4058e6
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: g1
  id: parameter
  parameters:
    label: '"Chan 1 gain"'
    type: eng_float
    value: '75'
  states: {}
- name: g2
  id: parameter
  parameters:
    label: '"Chan 2 gain"'
    type: eng_float
    value: '75'
  states: {}
- name: g3
  id: parameter
  parameters:
    label: '"Chan 3 gain"'
    type: eng_float
    value: '75'
  states: {}
- name: g4
  id: parameter
  parameters:
    label: '"Chan 4 gain"'
    type: eng_float
    value: '75'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: rx_time_catcher
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Catch the first rx_timestamp"""

          def __init__(self, rxfile="rxfile.txt",fftsize=32,crate=2500,srate=25e6):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='rx_time catcher',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.rxfile = rxfile
              self.first = True
              
              #
              # FFT outputs occur at srate/fftsize
              #
              self.fftrate = srate/fftsize
              
              #
              # This is then decimated at "self.decim" to produce the actual outputs
              #
              self.decim = self.fftrate / crate
              
              #
              # Which means the first output sample is produced at a time that is
              #  offset from the first input sample
              #
              self.offset = (1.0/self.fftrate) * self.decim

          def work(self, input_items, output_items):
              if (self.first == True):
                  # Get rx_time tag
                  self.first = False
                  tags = self.get_tags_in_window(0, 0, len(input_items[0]))
                  for tag in tags:
                      key = pmt.to_python(tag.key) # convert from PMT to python string
                      value = pmt.to_python(tag.value) # Note that the type(value) can be several things, it depends what PMT type it was
                      if (key == "rx_time"):
                          break
                  fp = open(self.rxfile, "w")
                  #fp.write("%s" % str(value))
                  timestump = float(value[0])+float(value[1])
                  timestump += self.offset
                  fp.write("%13.7f\n" % timestump)
                  fp.close()
              return len(input_items[0])
    crate: samp_rate/fft_size/decimation_factor
    fftsize: '32'
    rxfile: base_name + "_ts.txt"
    srate: samp_rate
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 2.5e7
  states: {}
- name: seconds
  id: parameter
  parameters:
    label: Seconds
    type: intx
    value: '3600'
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: alpha_IIR
    type: float
    vlen: fft_size
  states: {}
- name: single_pole_iir_filter_xx_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: alpha_IIR
    type: float
    vlen: fft_size
  states: {}
- name: time_catcher
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time
      import math
      from gnuradio.fft import window
      import os
      import signal

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Time Catcher"""

          def __init__(self, fftsize=32,tsfile="tsfile.txt"):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Time Catcher',   # will show up in GRC
                  in_sig=[(np.float32,fftsize)],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.fftsize = fftsize
              self.tsfile = tsfile
              self.first = True
              

          def work(self, input_items, output_items):
              """Capture timestamp on first record"""
              if (self.first == True):
                  fp = open(self.tsfile, "w")
                  fp.write("%13.6f\n" % time.time())
                  fp.close()
                  self.first = False
              return len(input_items[0])
    fftsize: fft_size
    tsfile: base_name + "_2_ts.txt"
  states: {}
- name: time_catcher_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time
      import math
      from gnuradio.fft import window
      import os
      import signal

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Time Catcher"""

          def __init__(self, fftsize=32,tsfile="tsfile.txt"):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Time Catcher',   # will show up in GRC
                  in_sig=[(np.float32,fftsize)],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.fftsize = fftsize
              self.tsfile = tsfile
              self.first = True
              

          def work(self, input_items, output_items):
              """Capture timestamp on first record"""
              if (self.first == True):
                  fp = open(self.tsfile, "w")
                  fp.write("%13.6f\n" % time.time())
                  fp.close()
                  self.first = False
              return len(input_items[0])
    fftsize: fft_size
    tsfile: base_name + "_1_ts.txt"
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX1
    ant1: RX2
    center_freq0: f1
    center_freq1: f2
    clock_rate: 200e6
    clock_source0: external
    dev_addr: addr=192.168.40.2,type=x300
    dev_args: master_clock_rate=200e6
    gain0: g1
    gain1: g2
    lo_export0: 'True'
    lo_export1: 'False'
    lo_source1: companion
    nchan: '2'
    samp_rate: samp_rate
    sd_spec0: '"A:0 A:1"'
    show_lo_controls: 'True'
    sync: pc_clock_next_pps
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', single_pole_iir_filter_xx_0_0, '0']
- [blocks_head_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_file_sink_0, '0']
- [blocks_keep_one_in_n_0, '0', time_catcher_0, '0']
- [blocks_keep_one_in_n_0_0, '0', blocks_file_sink_1, '0']
- [blocks_keep_one_in_n_0_0, '0', time_catcher, '0']
- [blocks_keep_one_in_n_2, '0', rx_time_catcher, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_keep_one_in_n_0, '0']
- [single_pole_iir_filter_xx_0_0, '0', blocks_keep_one_in_n_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_head_0, '0']
- [uhd_usrp_source_0, '1', blocks_keep_one_in_n_2, '0']
- [uhd_usrp_source_0, '1', blocks_stream_to_vector_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
